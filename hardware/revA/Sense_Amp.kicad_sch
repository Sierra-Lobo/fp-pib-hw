File: hardware/revA/Sense_Amp.kicad_sch (KiCad schematic)
At the start: 3 parts, among them U17 INA240A3EDRQ1

Commit message: working revB
Other:
- company: (none) -> Sierra Lobo INC
